# Repository uinika/Egret-Board

File README.md:

# Egret

一个基于 ESP32-PICO-D4 的核心板项目

[《ESP32-PICO-KIT V4/V4.1 入门指南》](https://docs.espressif.com/projects/esp-idf/zh_CN/latest/esp32/hw-reference/esp32/get-started-pico-kit.html)

## KiCad design Hardware/Egret.kicad_pcb

Parts:
C1: 0.1uF/25V (NC); C_0603_1608Metric
C2, C6, C15: 0.1uF/25V (10%); C_0603_1608Metric
C3: 2.7pF; C_0603_1608Metric
C4: 10uF/6.3V (10%); C_0603_1608Metric
C5: 4.7pF; C_0603_1608Metric
C7: 10nF; C_0603_1608Metric
C8, C13: 10uF/25V (10%); C_0603_1608Metric
C9, C12, C14: 0.1uF; C_0603_1608Metric
C10: 0.1uF/25V; C_0603_1608Metric
C11: 2.2nF; C_0603_1608Metric
Card1: TF-02A_C2889261; TF-SMD_TF-02
D1: Red LED; LED_0603_1608Metric
L1: 1.6nH; L_0603_1608Metric
Q1, Q2: S8050; SOT-23
Q3: AO3415AL; SOT-23-3_L2.9-W1.6-P1.90-LS2.9-BL
R1, R2, R6: 0R (1%); R_0603_1608Metric
R3: 0.1uF/25V (10%); R_0603_1608Metric
R4: 10K (5%)(NC); R_0603_1608Metric
R5: 2k (1%); R_0603_1608Metric
R7: 47.5K(1%); R_0603_1608Metric
R8, R9: 1K (1%); R_0603_1608Metric
R10, R11: 0R (1%)(NC); R_0603_1608Metric
R12: 22.1K(1%); R_0603_1608Metric
R13: 2K (1%); R_0603_1608Metric
R14: 10K (1%)(NC); R_0603_1608Metric
R15, R19, R20, R21, R22: 10k; R_0603_1608Metric
R16, R17: 10K (1%); R_0603_1608Metric
R18: 1k; R_0603_1608Metric
SW1, SW2: TD-1106SN-5.0H-160; SW-SMD_L6.0-W3.3-LS8.0-1
U1: WS2812B-B; LED_WS2812B-B; PARTREV 5
U2: AN2051-245_2.4G; ANT-SMD_L5.0-W2.0
U3: ESP32--PICO--D4; QFN-48_L7.0-W7.0-P0.50-BL-EP5.4
U4: MPU6050-YJLTY; QFN-24_L4.0-W4.0-P0.50-BL-EP2.7
U5: AMS1117-3.3; SOT-23-3_L2.9-W1.6-P1.90-LS2.9-BL
U6: BH1750FVI-TR; XDCR_BH1750FVI-TR; PARTREV D
U7: CP2102N-A02-GQFN28; QFN-28_L5.0-W5.0-P0.50-TL-EP3.3
U8, U9: FPC-SMD_8P-P0.5; FPC-SMD_8P-P0.5_C9900011879
U10: ST7789_FPC_PAD; ST7789-FPC-PAD
USB1: TYPEC-304J-BCP16; USB-C-SMD_TYPEC-304J-BCP16

Connections:
/CTS: R11.2, U7.23 (CTS)
/DTR: Q2.1 (E), R16.2, U7.28 (DTR)
/EN: Q1.3 (C), R6.2
/EXT_5V: C8.1, R5.1, R12.1, U1.1 (VDD), U5.3 (VI), USB1.A4B9 (VBUS), USB1.B4A9 (VBUS)
/FLASH_CLK: U3.31 (CLK)
/FLASH_CS: U3.25 (IO16)
/FLASH_SD0: U3.27 (IO17)
/FLASH_SD1: U3.33 (SD1)
/FLASH_SD2: U3.30 (CMD)
/FLASH_SD3: U3.32 (SD0)
/IO0: Q2.3 (C), R2.2, U3.23 (IO0)
/IO2: U3.22 (IO2), U8.5, U9.4, U10.7 (DC)
/IO4: U3.24 (IO4), U8.2, U9.7, U10.11 (RES)
/IO5: R18.2, U3.34 (IO5), U8.1, U9.8
/IO9: U3.28 (SD2)
/IO10: U3.29 (SD3)
/IO13: Card1.3 (CMD), R10.1, R20.1, U3.20 (IO13)
/IO14: Card1.5 (CLK), R21.1, U3.17 (IO14)
/IO15: Card1.2 (CD/DAT3), R11.1, R22.1, U3.21 (IO15)
/IO18: U3.35 (IO18), U8.4, U9.5, U10.9 (SCL)
/IO19: U3.38 (IO19)
/IO21: U3.42 (IO21)
/IO22: U3.39 (IO22)
/IO23: U3.36 (IO23), U8.3, U9.6, U10.10 (SDA)
/IO25: U3.14 (IO25)
/IO26: Card1.7 (DAT0), R19.1, U3.15 (IO26)
/IO27: U1.4 (DIN), U3.16 (IO27)
/IO32: U3.12 (IO32), U4.24 (SDA), U6.4 (SDA)
/IO33: U3.13 (IO33), U4.23 (SCL), U6.6 (SCL)
/IO34: U3.10 (IO34)
/IO35: U3.11 (IO35)
/IO37: U3.6 (SENSOR_CAPP)
/IO38: U3.7 (SENSOR_CAPN)
/RTS: Q1.1 (E), R10.2, R17.2, U7.24 (RTS)
/RXD: R8.2, U7.25 (RXD)
/RXD0: R9.1, U3.40 (U0RXD)
/SENSOR_VN: U3.8 (SENSOR_VN)
/SENSOR_VP: U3.5 (SENSOR_VP)
/TXD: R9.2, U7.26 (TXD)
/TXD0: R8.1, U3.41 (U0TXD)
/USB_DN: U7.5 (D-), USB1.A7 (DN1), USB1.B7 (DN2)
/USB_DP: U7.4 (D+), USB1.A6 (DP1), USB1.B6 (DP2)
/VDD33: C7.1, C12.1, C13.1, C14.1, C15.1, Card1.4 (VDD), Q3.2 (S), R1.2, R4.2, R13.2, R15.2, R19.2, R20.2, R21.2, R22.2, U4.8 (VLOGIC), U4.13 (VDD), U5.2 (VO), U6.1 (VCC), U7.6 (VDD), U7.7 (VREGIN), U8.7, U8.8, U9.1, U9.2, U10.4 (VDD)
/VDD33A: C4.1, C6.1, R1.1, R3.1, U3.1 (VDDA), U3.3 (VDDA3P3), U3.4 (VDDA3P3), U3.19 (VDD3P3_RTC), U3.37 (VDD3P3_CPU), U3.43 (VDDA), U3.46 (VDDA)
GND: C1.1, C2.2, C3.2, C4.2, C6.2, C7.2, C8.2, C9.1, C10.1, C11.2, C12.2, C13.2, C14.2, C15.2, Card1.6 (VSS), Card1.9 (CD), Card1.10 (GND), Card1.11 (GND), Card1.12 (GND), Card1.13 (GND), D1.1 (K), L1.2, R7.1, R14.2, SW1.1, SW2.1, U1.3 (VSS), U3.49 (GND), U4.1 (CLKIN), U4.9 (AD0), U4.11 (FSYNC), U4.18 (GND), U5.1 (GND), U6.2 (ADDR), U6.3 (GND), U7.3 (GND), U7.29 (EP), U8.6, U9.3, U10.1 (GND), U10.2 (LEDK), U10.5 (GND), U10.6 (GND), U10.8 (CS), U10.12 (GND), USB1.13 (GND), USB1.14 (GND), USB1.15 (GND), USB1.16 (GND), USB1.A1B12 (GND), USB1.B1A12 (GND)
unnamed: C1.2, R2.1, SW1.2
unnamed: C2.1, R3.2, U3.9 (EN)
unnamed: C3.1, C5.2, U2.1 (ANT)
unnamed: C5.1, L1.1, U3.2 (LNA_IN)
unnamed: C9.2, U4.10 (REGOUT)
unnamed: C10.2, R6.1, SW2.2
unnamed: C11.1, U4.20 (CPOUT)
unnamed: D1.2 (A), R5.2
unnamed: Q1.2 (B), R16.1
unnamed: Q2.2 (B), R17.1
unnamed: Q3.1 (G), R18.1
unnamed: Q3.3 (D), U10.3 (LEDA)
unnamed: R4.1, U3.18 (IO12)
unnamed: R7.2, R12.2, U7.8 (VBUS)
unnamed: R13.1, U7.9 (RSTb)
unnamed: R14.1, U7.11 (SUSPENDb)
unnamed: R15.1, U6.5 (DVI)

Notes on the sheet:
USB与串口
Auto program DTR RTS-->EN IO0 1 1 1 1 0 0 1 1 1 0 0 1 0 1 1 0
WS2812B RGB LED
TF 存储卡
AMS1117-3.3 电源
MP6050 加速度传感器
ST7789 液晶显示屏
BH1750 光线传感器
ESP32 最小系统

Board: 2 copper layers, 64.6 x 60.3 mm, 56 parts (9 on the bottom side), 44 nets.

## KiCad design Demo/Egret.kicad_pcb

Parts:
C1, C7: 10nF; C_0603_1608Metric
C2, C3, C4, C8, C9, C10: 0.1uF; C_0603_1608Metric
C5: 2.2nF; C_0603_1608Metric
C6, C11: 10uF; C_0603_1608Metric
Card1: TF-02A_C2889261; TF-SMD_TF-02
FPC1: FPC-05F-12PH20; FPC-SMD_12P-P0.50_FPC-05F-12PH20
Q1, Q2: S8050; SOT-23
Q3: AO3415AL; SOT-23-3_L2.9-W1.6-P1.90-LS2.9-BL
R1, R2, R7, R9, R10, R11, R12: 10k; R_0603_1608Metric
R3, R4: 12k; R_0603_1608Metric
R5: 1k; R_0603_1608Metric
R6: 200R; R_0603_1608Metric
R8: 0; R_0603_1608Metric
U1: WS2812B-B; LED_WS2812B-B; PARTREV 5
U2: MPU6050; IC_MPU6050; PARTREV 3.4
U3: LP2992IM5-3.3; SOT95P280X145-5N
U4: BH1750FVI-TR; XDCR_BH1750FVI-TR; PARTREV D
U5: ESP32-PICO-D4; PQFN50P700X700X104-49N; PARTREV v1.9
U6: AN2051-245_2.4G全向天线; ANT-SMD_L5.0-W2.0
U7: CP2102N-A01-GQFN28; QFN50P500X500X80-29N; PARTREV 1.0
USB1: TYPEC-304J-BCP16; USB-C-SMD_TYPEC-304J-BCP16

Connections:
+3V3: C2.2, C3.1, C6.2, C7.1, C9.1, Card1.4 (VDD), FPC1.4, Q3.2 (S), R1.2, R2.1, R8.1, R9.2, R10.2, R11.2, R12.2, U2.8 (VLOGIC), U2.13 (VDD), U3.5 (VOUT), U4.1 (VCC)
+5V: R7.1, U1.1 (VDD), U3.1 (VIN), U3.3 (ON/~OFF), U7.7 (VREGIN), U7.8 (VBUS), USB1.A4B9 (VBUS)
/3V3A: C10.1, C11.1, R8.2, U5.1 (VDDA), U5.3 (VDDA3P3), U5.4 (VDDA3P3), U5.19 (VDD3P3_RTC), U5.37 (VDD3P3_CPU), U5.43 (VDDA), U5.46 (VDDA)
/CP_Rx: U5.41 (U0TXD), U7.25 (RXD)
/CP_Tx: R6.1, U5.40 (U0RXD)
/DTR: Q2.1 (E), R3.2, U7.28 (DTR)
/EN: C8.1, Q1.3 (C), R2.2, U5.9 (EN)
/FLASH_CLK: U5.31 (CLK)
/FLASH_CS: U5.25 (IO16)
/FLASH_SD0: U5.27 (IO17)
/FLASH_SD1: U5.33 (SD1)
/FLASH_SD2: U5.30 (CMD)
/FLASH_SD3: U5.32 (SD0)
/GPIO0: Q2.3 (C), U5.23 (IO0)
/GPIO2/DC: FPC1.7, U5.22 (IO2)
/GPIO4/RES: FPC1.11, U5.24 (IO4)
/GPIO5/LCD_BL: R5.2, U5.34 (IO5)
/GPIO9: U5.28 (SD2)
/GPIO10: U5.29 (SD3)
/GPIO12: U5.18 (IO12)
/GPIO13/SD_MOSI: Card1.3 (CMD), R10.1, U5.20 (IO13)
/GPIO14/SD_CLK: Card1.5 (CLK), R11.1, U5.17 (IO14)
/GPIO15/SD_CS: Card1.2 (CD/DAT3), R12.1, U5.21 (IO15)
/GPIO18/SCK: FPC1.9, U5.35 (IO18)
/GPIO19: U5.38 (IO19)
/GPIO21: U5.42 (IO21)
/GPIO22: U5.39 (IO22)
/GPIO23/MOSI: FPC1.10, U5.36 (IO23)
/GPIO25: U5.14 (IO25)
/GPIO26/SD_MISO: Card1.7 (DAT0), R9.1, U5.15 (IO26)
/GPIO27/RGB_LED: U1.4 (DIN), U5.16 (IO27)
/GPIO32/MPU_SDA/BH_SDA: U2.24 (SDA), U4.4 (SDA), U5.12 (IO32)
/GPIO33/MPU_SCL/BH_SCL: U2.23 (SCL), U4.6 (SCL), U5.13 (IO33)
/RTS: Q1.1 (E), R4.2, U7.24 (RTS)
/USB-PWR-DN: U7.5 (D-), USB1.A7 (DN1), USB1.B7 (DN2)
/USB-PWR-DP: U7.4 (D+), USB1.A6 (DP1), USB1.B6 (DP2)
GND: C1.2, C2.1, C3.2, C4.2, C5.2, C6.1, C7.2, C8.2, C9.2, C10.2, C11.2, Card1.6 (VSS), Card1.9 (CD), Card1.10 (GND), Card1.11 (GND), Card1.12 (GND), Card1.13 (GND), FPC1.1, FPC1.2, FPC1.5, FPC1.6, FPC1.8, FPC1.12, U1.3 (VSS), U2.1 (CLKIN), U2.9 (AD0), U2.11 (FYSNC), U2.18 (GND), U3.2 (GND), U4.2 (ADDR), U4.3 (GND), U5.49 (GND), U7.3 (GND), U7.29 (GND), USB1.13 (GND), USB1.14 (GND), USB1.15 (GND), USB1.16 (GND), USB1.A1B12 (GND)
unnamed: C1.1, U3.4 (BYPASS)
unnamed: C4.1, U2.10 (REGOUT)
unnamed: C5.1, U2.20 (CPOUT)
unnamed: FPC1.3, Q3.3 (D)
unnamed: Q1.2 (B), R3.1
unnamed: Q2.2 (B), R4.1
unnamed: Q3.1 (G), R5.1
unnamed: R1.1, U4.5 (DVI)
unnamed: R6.2, U7.26 (TXD)
unnamed: R7.2, U7.9 (~RST)
unnamed: U5.2 (LNA_IN), U6.1 (ANT)

Notes on the sheet:
ST7789 液晶屏
线性稳压器
TF 存储卡
微控制器
加速度传感器
USB 转串口芯片

Board: 2 copper layers, 43.7 x 50.3 mm, 36 parts (0 on the bottom side), 35 nets.

## Commit log

2022-06-13 initialization commit.
2022-06-13 update schematic.
2022-06-13 add additional libraries.
2022-06-14 generate PCB files.
2022-06-15 fix some bugs
2022-06-15 generate PCB board
2022-06-28 reorganize component locations
2022-06-28 PCB layout
2022-06-29 update PCB
2022-07-08 add new demo
2022-07-18 pudate
